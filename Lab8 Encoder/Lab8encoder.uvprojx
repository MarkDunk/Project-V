# Keil uVision project Lab8encoder.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab8encoder
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Encoder.c Encoder.h LED.c LED.h main.c startup_stm32f303xe.s SysClock.c SysClock.h system_stm32f3xx.c UART.c UART.h utility.c utility.h
software components: CMSIS:CORE 6.0.0
